# Keil uVision project quoridor.uvprojx, settings and files
target Quoridor (6210000::V6.21::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: quoridor
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./src/: main.c
  group lib_SoC_board
    ./: system_LPC17xx.c
  group GLCD
    ./src/GLCD/: AsciiLib.c GLCD.c HzLib.c
  group utils
    ./src/utils/: astar.c comparable.c dyn_array.c min_heap.c sort.c stack.c
  group imgs
    ./src/imgs/: cell.c player.c wall.c
  group button_EXINT
    ./src/button_EXINT/: IRQ_button.c lib_button.c
  group joystick
    ./src/joystick/: lib_joystick.c
  group RIT
    ./src/RIT/: IRQ_RIT.c lib_RIT.c
  group game
    ./src/game/: game.c graphics.c npc.c
  group CAN
    ./src/CAN/: IRQ_CAN.c lib_CAN.c
software components: CMSIS:CORE 5.6.0
